# Keil uVision project IRControl.uvprojx, settings and files
target IRControl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F070F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: IRControl +hex
  AfterMake: fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F070x6,IsApp =1
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Drivers\inc;..\user;..\ptos;..\modbus
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x200000c0 size 0x1740
  group stm32f070
    ../Src/: system_stm32f0xx.c stm32f0xx_misc.c
    ./: startup_stm32f070x6.s
  group user
    ../Src/: main.c stm32f0xx_it.c
    ../user/: bsp_driver.c app.c ringbuffer.c ymodem.c bsp_driver.h ringbuffer.h ymodem.h ble_driver.c ble_driver.h log.h
    ../Inc/: main.h
  group bsp_driver
    ../Drivers/src/: stm32f0xx_tim.c stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_flash.c
  group mbs
    ../modbus/: Modbus_Core.c Modbus_CRC.c Modbus_hook.c Modbus_User.c Modbus_CORE.h Modbus_CRC.h Modbus_hook.h Modbus_USER.h
software components: CMSIS:CORE 4.3.0
